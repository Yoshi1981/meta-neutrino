include neutrino-plugins-ni-env.inc

DESCRIPTION = "STP-Update"
