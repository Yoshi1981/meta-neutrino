include neutrino-plugins-ni-env.inc

DESCRIPTION = "Satfinder"
