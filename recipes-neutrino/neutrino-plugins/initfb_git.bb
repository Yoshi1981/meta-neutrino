include neutrino-plugins-ni-env.inc

DESCRIPTION = "Init frambuffer"
MAINTAINER ?= "BPanther"
HOMEPAGE ?= "https://forum.mbremer.de"
