include neutrino-plugins-ni-env.inc

DESCRIPTION = "Power off for VU+"

# fix wrong path name, underline is a bad idea
SUB_PATH = "turnoff_power"
