include neutrino-plugins-ni-env.inc

DESCRIPTION = "OLED Control"

# fix wrong path name, underline is a bad idea
SUB_PATH = "oled_ctrl"
